# Keil uVision project W7500x_FreeRTOS_UART_CLI.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: W7500x_FreeRTOS_UART_CLI
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --vhx --8x1 --output main.hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4
  c define: CORTEX_M0 USE_STDPERIPH_DRIVER
  c include: ..\..\W7500x_Library_Examples\W7500x_Library_Examples\Libraries\CMSIS\Device\WIZnet\W7500\Include;..\..\W7500x_Library_Examples\W7500x_Library_Examples\Libraries\W7500x_stdPeriph_Driver\inc;..\..\W7500x_Library_Examples\W7500x_Library_Examples\Libraries\CMSIS\Include;..\;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM0;..\..\W7500x_Library_Examples\W7500x_Library_Examples\ioLibrary\MDIO
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group MDK-ARM
    ./: startup_W7500x.s
  group W7500_Periph
    ../../W7500x_Library_Examples/W7500x_Library_Examples/Libraries/W7500x_stdPeriph_Driver/src/: W7500x_gpio.c W7500x_uart.c W7500x_wztoe.c
    ../../W7500x_Library_Examples/W7500x_Library_Examples/ioLibrary/MDIO/: W7500x_miim.c
  group CMSIS
    ../../W7500x_Library_Examples/W7500x_Library_Examples/Libraries/CMSIS/Device/WIZnet/W7500/Source/: system_W7500x.c
  group User
    ../: main.c retarget.c W7500x_it.c leds.c util.c
  group FreeRTOS
    ../: CLI-commands.c FreeRTOS_CLI.c serial.c UARTCommandConsole.c
    ../../FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
    ../../FreeRTOS/portable/RVDS/ARM_CM0/: port.c
    ../../FreeRTOS/portable/MemMang/: heap_2.c
